# IAR project Backup of Boot.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: APM32F407VG Geehy APM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F40X
  ICCARM.CCIncludePath2: ../Core/Inc; ..\Drivers\APM32F4xx_StdPeriphDriver\inc; ..\Drivers\Device\Geehy\APM32F4xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Boot.bin
  ILINK.IlinkOutputFile: Boot.out
  ILINK.IlinkIcfFile: Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../Core/Src/: apm32f4xx_int.c main.c
  group Application/EWARM
    ../Drivers/Device/Geehy/APM32F4xx/Source/iar/: startup_apm32f40x.s
  group Drivers/APM32F4xx_StdPeriphDriver/inc
    ../Drivers/APM32F4xx_StdPeriphDriver/inc/: apm32f4xx_adc.h apm32f4xx_dma.h apm32f4xx_gpio.h apm32f4xx_misc.h apm32f4xx_rcm.h apm32f4xx_spi.h apm32f4xx_syscfg.h apm32f4xx_usart.h
  group Drivers/APM32F4xx_StdPeriphDriver/src
    ../Drivers/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_adc.c apm32f4xx_dma.c apm32f4xx_gpio.c apm32f4xx_misc.c apm32f4xx_rcm.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_usart.c
  group Drivers/CMSIS
    ../Drivers/Device/Geehy/APM32F4xx/Source/: system_apm32f4xx.c
